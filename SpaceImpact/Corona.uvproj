# Keil uVision project Corona.uvproj, settings and files
target Corona (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Corona
  c flags: Optim=1 OneElfS=1 uC99=1
  c misc: -DSIMULATION
  c include: .\src\include;.\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: ADC.c CollisionDetector.c Corona.c GameEngine.c Graphics.c IO.c Nokia5110.c Objects.c Path.c startup.s SysClockCfg.c Timer.c Sound.c PWM.c UART.c DAC.c
